File: hardware/ethernet.kicad_sch (KiCad schematic)
At the start: 31 parts, among them IC2 RTL8201F-VB-CG, J1 JXD1-0009NL, X1 SG-5032CCN

Commit message: test
Other:
- moved on the sheet: D2
